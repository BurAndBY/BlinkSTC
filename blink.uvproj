# Keil uVision project blink.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104E STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: blink +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
